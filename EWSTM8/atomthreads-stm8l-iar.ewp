# IAR project atomthreads-stm8l-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: ATOM_STACK_CHECKING
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: C:\Users\admin\Desktop\atomthreads_template_STM8L\Driver; C:\Users\admin\Desktop\atomthreads_template_STM8L\kernel; C:\Users\admin\Desktop\atomthreads_template_STM8L\STM8L15x_StdPeriph_Driver\inc; C:\Users\admin\Desktop\atomthreads_template_STM8L\user; C:\Users\admin\Desktop\atomthreads_template_STM8L
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: atomthreads-stm8l-iar.bin
  ILINK.IlinkOutputFile: atomthreads.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: NDEBUG; STM8S105
  group driver
    ../Driver/: drv_pin.c drv_uart.c
  group kernel
    ../kernel/: atom.h atomkernel.c atommutex.c atommutex.h atomport-template.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h
  group stdperiph_driver_inc
    ../STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group stdperiph_driver_src
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_dma.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_tim1.c stm8l15x_usart.c
  group user
    ../kernel/: atomport-asm-iar.s
    ../user/: atomport-private.h atomport.c atomport.h main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
